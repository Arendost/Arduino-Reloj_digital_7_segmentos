
void segundo()
{ 

t2=(millis()/1000);
if ( t1 != t2 ){
 t1=t2;
 s2++;
 flag=0; 
}
if (s2==10) {
s2=0;
s1++;
 } 
}

void minutos(){
if ((s1==6) && (s2==0)){
s1=0;   
m2++;   
 }
if (m2==10){
m2=0;   
m1++; 
 } 
}

void horas(){ 
if ((m1==6) && (m2==0)) {
m1 =0; 
h2++;}
   
if (h2==10) {
h2=0;
h1++; } 

if ((h1==1)&&(h2>2)){   
h1=1;
h2=2;
m1=0;
m2=0;
s1=0;
s2=0;
}

if ((h1==0)&&(h2==0)){ 
h1=1;
h2=2;
m1=0;
m2=0;
s1=0;
s2=0;
 }  
}

void tiempo() { 

  if ((h1==1)&& (h2==2) && (m1==5) && (m2==9) && (s1==5) && (s2==9)){
    h1=0;
    h2=1;    
    m1=0;
    m2=0;
    s1=0;
    s2=0;
  }
}
